# Keil uVision project DisplayPrototype.uvprojx, settings and files
target DisplayPrototype (ARM-ADS)
  device: STM32F302R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: DisplayPrototype
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302x8
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F3xx_HAL_Driver/Inc;  ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;  ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;  ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;  ../Drivers/CMSIS/Include;  ../Drivers/CMSIS/Device/ST/STM32F3xx/Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f302x8.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal.c stm32f3xx_hal_pwr.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_flash.c stm32f3xx_hal_rcc.c stm32f3xx_hal_pcd.c stm32f3xx_hal_i2c.c stm32f3xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Application/User
    ../Src/: usbd_conf.c main.c usbd_desc.c usb_device.c stm32f3xx_hal_msp.c stm32f3xx_it.c
software components: CMSIS:CORE 4.1.0
